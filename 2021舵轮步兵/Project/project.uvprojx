# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT
  c include: ..\APP;..\BSP;..\Libraries\inc;..\Libraries\src;..\Libraries\cmsis\Include;..\Libraries\cmsis;..\SYSTEM;..\IMU-mpu6050;..\IMU-mpu6050\eMPL;..\IMU-BMI270;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SYSTEM
    ../SYSTEM/: usart.c sys.c
  group FPU
    ../Libraries/Device/: arm_mat_init_f32.c arm_mat_trans_f32.c arm_mat_sub_f32.c arm_mat_scale_f32.c arm_mat_mult_f32.c arm_mat_inverse_f64.c arm_mat_inverse_f32.c arm_mat_add_f32.c arm_cortexM4lf_math.lib
  group STM32_StdPeriph
    ../Libraries/startup/: startup_stm32f40xx.s
    ../Libraries/src/: misc.c stm32f4xx_syscfg.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_iwdg.c
    ../Libraries/cmsis/: system_stm32f4xx.c
  group HEADER
    ../BSP/: Driver.h Device.h Function.h
    ../APP/: GO.h system.h
  group APP
    ../APP/: main.c stm32f4xx_it.c GO.c system.c zigbee_upper.c FreeRTOS_Init.c iwdg.c
    ../BSP/: Sonic.c
  group BSP
    ../BSP/: can1.c can2.c led.c TIM.c uart4.c uart1.c uart3.c
    ../IMU-mpu6050/: myiic.c
  group MPU6050
    ../IMU-mpu6050/: mpu6050.c
    ../IMU-mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group BMI270
    ../IMU-BMI270/: bmi.c bmi2.c bmi2_common.c bmi2_ois.c bmi270.c bmi270_context.c
  group FUNCTION
    ../BSP/: vision.c BUFF.c AUTO.c
  group MATH
    ../BSP/: crc.c SinCosTable.c kalman.c
  group Referee
    ../BSP/: masters_RTX.c CUSUI.c referee.c
  group DEVICE
    ../BSP/: system_state.c gimbal.c rudder.c remote.c chassis.c module.c rifle.c motor.c my_imu.c PID.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
